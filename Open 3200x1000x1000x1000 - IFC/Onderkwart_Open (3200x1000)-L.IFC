Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Export from Compass
File name: Architecten pagina_Onderkwart_Open (3200x1000)-L.IFC
Time: 2019-07-26T08:13:28
Author: Compass
Organization: Compass Software GmbH
Written by: De Vries Trappen BV
Made in: De Vries Trappen BV
Authorization: staircase file created for IFC import

# IfcBuildingElementPart: IFCStair (22)
In: Buildingstorey
Group: STAIR - OTHERS

# IfcGroup: IFCStair, STAIR - OTHERS
Description: OTHERS; Group: Stair assembly

# IfcStair, Open (3200x1000)-L
In: Buildingstorey
Description: staircase; ShapeType: QUARTER_WINDING_STAIR
CS_Set_Dimensions - Aantrede: 220 mm; Optredehoogte: 187.5 mm; Doorloophoogte: 2768.99 mm
CS_Set_Materials - Treden: vuren; Stootborden: mdf; Spil: grenen fsc mix; Bomen: vuren
CS_Set_Others - Barcode: 99PY; Auftragsname:: Architecten pagina; Specificaties: Voor deze trap gelden de specificaties en detailleringen als beschreven in de (meest recente) separaat verzonden specificatiebladen.; Voorbehoud: Aan dit model kunnen geen rechten worden ontleend t.a.v. materiaal, kleur en profilering.; Bestekparagraaf (Stabu): NL_32
